options:
  parameters:
    generate_options: no_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: constellation_qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: max_pathloss_db
  id: variable
  parameters:
    value: '107.76'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: total_prb
  id: variable
  parameters:
    value: '52'
  states: {}
- name: ue1_pathloss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue1_prb
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ue2_pathloss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue2_prb
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ue3_pathloss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue3_prb
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ue4_pathloss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue4_prb
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ue5_pathloss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue5_prb
  id: variable
  parameters:
    value: '2'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_ue1_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue1_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue2_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue2_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue3_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue3_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue4_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue4_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue5_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue5_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_pathloss_db/20.0)
    type: complex
  states: {}
- name: blocks_ue_tx_to_gnb_rx_add
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_3
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_4
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_1
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_2
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_3
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_4
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation_qpsk
  states: {}
- name: digital_ofdm_rx_1_0
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue1_prb * 12) / 2), 0)) + list(range(1, int((1 * ue1_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_rx_1_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue2_prb * 12) / 2), 0)) + list(range(1, int((1 * ue2_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_rx_1_0_1
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue3_prb * 12) / 2), 0)) + list(range(1, int((1 * ue3_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_rx_1_0_2
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue4_prb * 12) / 2), 0)) + list(range(1, int((1 * ue4_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_rx_1_0_3
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue5_prb * 12) / 2), 0)) + list(range(1, int((1 * ue5_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_rx_1_0_4
  id: digital_ofdm_rx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * total_prb * 12) / 2), 0)) + list(range(1, int((1 * total_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * total_prb * 12) / 2), 0)) + list(range(1, int((1 * total_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4_0
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue1_prb * 12) / 2), 0)) + list(range(1, int((1 * ue1_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue2_prb * 12) / 2), 0)) + list(range(1, int((1 * ue2_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4_0_1
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue3_prb * 12) / 2), 0)) + list(range(1, int((1 * ue3_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4_0_2
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue4_prb * 12) / 2), 0)) + list(range(1, int((1 * ue4_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: digital_ofdm_tx_0_4_0_3
  id: digital_ofdm_tx
  parameters:
    cp_len: int(0.07*fft_length)
    fft_len: fft_length
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(int((-1 * ue5_prb * 12) / 2), 0)) + list(range(1, int((1 * ue5_prb * 12) / 2)))]'
    packet_len_key: ''
    payload_mod: '"QPSK"'
    pilot_carriers: '[[ -21, -7, 7, 21 ]]'
    pilot_symbols: '[[1, 1, 1, -1]]'
    rolloff: '0'
    sync_word1: '[0] * fft_length'
    sync_word2: '[1] * fft_length'
  states: {}
- name: zeromq_gnb_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_gnb_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue1_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue1_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue2_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue2_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue3_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue3_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue4_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2400
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue4_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2401
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue5_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2500
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue5_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2501
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_ue1_rx_pathloss, '0', digital_ofdm_rx_1_0, '0']
- [blocks_ue1_tx_pathloss, '0', blocks_ue_tx_to_gnb_rx_add, '0']
- [blocks_ue2_rx_pathloss, '0', digital_ofdm_rx_1_0_0, '0']
- [blocks_ue2_tx_pathloss, '0', blocks_ue_tx_to_gnb_rx_add, '1']
- [blocks_ue3_rx_pathloss, '0', digital_ofdm_rx_1_0_1, '0']
- [blocks_ue3_tx_pathloss, '0', blocks_ue_tx_to_gnb_rx_add, '2']
- [blocks_ue4_rx_pathloss, '0', digital_ofdm_rx_1_0_2, '0']
- [blocks_ue4_tx_pathloss, '0', blocks_ue_tx_to_gnb_rx_add, '3']
- [blocks_ue5_rx_pathloss, '0', digital_ofdm_rx_1_0_3, '0']
- [blocks_ue5_tx_pathloss, '0', blocks_ue_tx_to_gnb_rx_add, '4']
- [blocks_ue_tx_to_gnb_rx_add, '0', digital_ofdm_rx_1_0_4, '0']
- [digital_constellation_decoder_cb_0, '0', digital_ofdm_tx_0_4, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_ofdm_tx_0_4_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_ofdm_tx_0_4_0_0, '0']
- [digital_constellation_decoder_cb_0_2, '0', digital_ofdm_tx_0_4_0_1, '0']
- [digital_constellation_decoder_cb_0_3, '0', digital_ofdm_tx_0_4_0_2, '0']
- [digital_constellation_decoder_cb_0_4, '0', digital_ofdm_tx_0_4_0_3, '0']
- [digital_constellation_encoder_bc_0, '0', zeromq_ue1_rx, '0']
- [digital_constellation_encoder_bc_0_0, '0', zeromq_ue2_rx, '0']
- [digital_constellation_encoder_bc_0_1, '0', zeromq_ue3_rx, '0']
- [digital_constellation_encoder_bc_0_2, '0', zeromq_ue4_rx, '0']
- [digital_constellation_encoder_bc_0_3, '0', zeromq_ue5_rx, '0']
- [digital_constellation_encoder_bc_0_4, '0', zeromq_gnb_rx, '0']
- [digital_ofdm_rx_1_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_ofdm_rx_1_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [digital_ofdm_rx_1_0_1, '0', digital_constellation_encoder_bc_0_1, '0']
- [digital_ofdm_rx_1_0_2, '0', digital_constellation_encoder_bc_0_2, '0']
- [digital_ofdm_rx_1_0_3, '0', digital_constellation_encoder_bc_0_3, '0']
- [digital_ofdm_rx_1_0_4, '0', digital_constellation_encoder_bc_0_4, '0']
- [digital_ofdm_tx_0_4, '0', blocks_ue1_rx_pathloss, '0']
- [digital_ofdm_tx_0_4, '0', blocks_ue2_rx_pathloss, '0']
- [digital_ofdm_tx_0_4, '0', blocks_ue3_rx_pathloss, '0']
- [digital_ofdm_tx_0_4, '0', blocks_ue4_rx_pathloss, '0']
- [digital_ofdm_tx_0_4, '0', blocks_ue5_rx_pathloss, '0']
- [digital_ofdm_tx_0_4_0, '0', blocks_ue1_tx_pathloss, '0']
- [digital_ofdm_tx_0_4_0_0, '0', blocks_ue2_tx_pathloss, '0']
- [digital_ofdm_tx_0_4_0_1, '0', blocks_ue3_tx_pathloss, '0']
- [digital_ofdm_tx_0_4_0_2, '0', blocks_ue4_tx_pathloss, '0']
- [digital_ofdm_tx_0_4_0_3, '0', blocks_ue5_tx_pathloss, '0']
- [zeromq_gnb_tx, '0', digital_constellation_decoder_cb_0, '0']
- [zeromq_ue1_tx, '0', digital_constellation_decoder_cb_0_0, '0']
- [zeromq_ue2_tx, '0', digital_constellation_decoder_cb_0_1, '0']
- [zeromq_ue3_tx, '0', digital_constellation_decoder_cb_0_2, '0']
- [zeromq_ue4_tx, '0', digital_constellation_decoder_cb_0_3, '0']
- [zeromq_ue5_tx, '0', digital_constellation_decoder_cb_0_4, '0']

metadata:
  file_format: 1
