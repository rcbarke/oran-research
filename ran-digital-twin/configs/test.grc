options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: zeromq_gnb_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*gnb_tx_channel_rate_var)
    type: complex
  states: {}
- name: ue1_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue1_rx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue1_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue1_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: ue2_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue2_rx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue2_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue2_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: ue3_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue3_rx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue3_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue3_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: ue4_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue4_rx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue4_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue4_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2400
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: ue5_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue5_rx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue5_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue5_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2500
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_ue1_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: blocks_ue1_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: ue1_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue1_tx_channel_rate_var)
    type: complex
  states: {}
- name: zeromq_ue2_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: blocks_ue2_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: ue2_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue2_tx_channel_rate_var)
    type: complex
  states: {}
- name: zeromq_ue3_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: blocks_ue3_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: ue3_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue3_tx_channel_rate_var)
    type: complex
  states: {}
- name: zeromq_ue4_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2401
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: blocks_ue4_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_path_loss_db/20.0)
    type: complex
  states: {}
- name: ue4_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue4_tx_channel_rate_var)
    type: complex
  states: {}
- name: zeromq_ue5_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2501
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: blocks_ue5_tx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_path_loss_db/20.0)
    type: complex
  states: {}
- name: ue5_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*ue5_tx_channel_rate_var)
    type: complex
  states: {}
- name: blocks_ue_tx_to_gnb_rx_add
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: gnb_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*gnb_rx_channel_rate_var)
    type: complex
  states: {}
- name: zeromq_gnb_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: gNB Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue1_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE1 Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue2_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE2 Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue3_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE3 Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue4_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE4 Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue5_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE5 Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue1_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE1 Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue2_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE2 Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue3_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE3 Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue4_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE4 Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: ue5_tx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: UE5 Tx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}
- name: gnb_rx_channel_rate_var
  id: variable_qtgui_range
  parameters:
    label: gNB Rx Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}

connections:
- [zeromq_gnb_tx, '0', gnb_tx_channel_rate, '0']
- [gnb_tx_channel_rate, '0', ue1_rx_channel_rate, '0']
- [ue1_rx_channel_rate, '0', blocks_ue1_rx_pathloss, '0']
- [blocks_ue1_rx_pathloss, '0', zeromq_ue1_rx, '0']
- [gnb_tx_channel_rate, '0', ue2_rx_channel_rate, '0']
- [ue2_rx_channel_rate, '0', blocks_ue2_rx_pathloss, '0']
- [blocks_ue2_rx_pathloss, '0', zeromq_ue2_rx, '0']
- [gnb_tx_channel_rate, '0', ue3_rx_channel_rate, '0']
- [ue3_rx_channel_rate, '0', blocks_ue3_rx_pathloss, '0']
- [blocks_ue3_rx_pathloss, '0', zeromq_ue3_rx, '0']
- [gnb_tx_channel_rate, '0', ue4_rx_channel_rate, '0']
- [ue4_rx_channel_rate, '0', blocks_ue4_rx_pathloss, '0']
- [blocks_ue4_rx_pathloss, '0', zeromq_ue4_rx, '0']
- [gnb_tx_channel_rate, '0', ue5_rx_channel_rate, '0']
- [ue5_rx_channel_rate, '0', blocks_ue5_rx_pathloss, '0']
- [blocks_ue5_rx_pathloss, '0', zeromq_ue5_rx, '0']
- [zeromq_ue1_tx, '0', blocks_ue1_tx_pathloss, '0']
- [blocks_ue1_tx_pathloss, '0', ue1_tx_channel_rate, '0']
- [ue1_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '0']
- [zeromq_ue2_tx, '0', blocks_ue2_tx_pathloss, '0']
- [blocks_ue2_tx_pathloss, '0', ue2_tx_channel_rate, '0']
- [ue2_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '1']
- [zeromq_ue3_tx, '0', blocks_ue3_tx_pathloss, '0']
- [blocks_ue3_tx_pathloss, '0', ue3_tx_channel_rate, '0']
- [ue3_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '2']
- [zeromq_ue4_tx, '0', blocks_ue4_tx_pathloss, '0']
- [blocks_ue4_tx_pathloss, '0', ue4_tx_channel_rate, '0']
- [ue4_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '3']
- [zeromq_ue5_tx, '0', blocks_ue5_tx_pathloss, '0']
- [blocks_ue5_tx_pathloss, '0', ue5_tx_channel_rate, '0']
- [ue5_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '4']
- [blocks_ue_tx_to_gnb_rx_add, '0', gnb_rx_channel_rate, '0']
- [gnb_rx_channel_rate, '0', zeromq_gnb_rx, '0']

metadata:
  file_format: 1
