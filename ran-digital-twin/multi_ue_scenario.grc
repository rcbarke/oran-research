options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: zeromq_gnb_tx
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb_tx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: gnb_channel_rate
    type: complex
  states: {}
- name: ue1_rx_channel_rate
  id: blocks_throttle
  parameters:
    samples_per_second: ue1_channel_rate
    type: complex
  states: {}
- name: blocks_ue1_rx_pathloss
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: zeromq_ue1_rx
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb_channel_rate
  id: variable_qtgui_range
  parameters:
    label: GNB Channel Rate
    start: '0'
    step: '1'
    stop: '32'
    value: '4'
  states: {}

connections:
- [zeromq_gnb_tx, '0', gnb_tx_channel_rate, '0']
- [gnb_tx_channel_rate, '0', ue1_rx_channel_rate, '0']
- [ue1_rx_channel_rate, '0', blocks_ue1_rx_pathloss, '0']
- [blocks_ue1_rx_pathloss, '0', zeromq_ue1_rx, '0']
- [zeromq_ue1_tx, '0', blocks_ue1_tx_pathloss, '0']
- [blocks_ue1_tx_pathloss, '0', ue1_tx_channel_rate, '0']
- [ue1_tx_channel_rate, '0', blocks_ue_tx_to_gnb_rx_add, '0']

metadata:
  file_format: 1
